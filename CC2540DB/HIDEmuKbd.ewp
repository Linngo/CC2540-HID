# IAR project HIDEmuKbd.ewp, settings and files
configuration CC2540DK-MINI Keyfob Slave (8051, debug)
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.CCDefines: INT_HEAP_LEN=1500; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_KEY=TRUE; HAL_LCD=FALSE; HAL_UART=TRUE; HAL_LED=TRUE; HAL_HID=TRUE; CC2540_MINIDK; GAP_CHAR_CFG_MAX=6
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540USB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\Roles; ..\..\Profiles\HidDevKbd\CC254x; ..\..\Profiles\HidDevKbd; ..\..\Profiles\HidDev\CC254x; ..\..\Profiles\DevInfo; ..\..\Profiles\Batt\CC254x; ..\..\Profiles\ScanParam\CC254x; ..\..\Profiles\ScanParam; ..\..\..\..\Components\hal\target\CC2540USB; ..\..\..\..\Components\hal\target\CC2540USB\usb\library; ..\..\..\..\Components\hal\target\CC2540USB\usb\library\cc2540_hid; ..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_hid; ..\..\..\..\Components\hal\target\CC2540USB\usb\class_hid; ..\..\..\..\Projects\ble\common\npi\npi_np; ..\..\..\..\Projects\ble\Profiles\SimpleProfile
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration test-SBL (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=1500; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_KEY=TRUE; HAL_LCD=FALSE; HAL_UART=TRUE; HAL_LED=TRUE; HAL_HID=TRUE; CC2540_MINIDK; GAP_CHAR_CFG_MAX=6; MAKE_CRC_SHDW; FEATURE_SBL; OAD_KEEP_NV_PAGES
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "test-SBL\Exe\HidEmuKbd"
  XLINK.XclFile: C:\BLE-CC254x-1.4.2.2.200_200\Projects\ble\common\cc2540\cc254x_f256_sbl.xcl
configuration testubl (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=1500; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_KEY=TRUE; HAL_LCD=FALSE; HAL_UART=TRUE; HAL_LED=TRUE; HAL_HID=TRUE; CC2540_MINIDK; GAP_CHAR_CFG_MAX=6; OAD_KEEP_NV_PAGES; FEATURE_UBL_MSD
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "testubl\Exe\USB-UBL"
  XLINK.XclFile: cc254x_f256_ubl_msd.xcl
  group APP
    ../Source/: Adc.c Display_EPD_W21.c Display_EPD_W21_Aux.c hidemukbd.c hidemukbd.h hidemukbd_Main.c led.c OSAL_hidemukbd.c Pwm.c spi.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540USB/Config
    ../../../../Components/hal/target/CC2540USB/: hal_board_cfg.h
  group HAL/Target/CC2540USB/Drivers
    ../../../../Components/hal/target/CC2540USB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540USB/Includes
    ../../../../Components/hal/target/CC2540USB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2540USB/USB/class_hid
    ../../../../Components/hal/target/CC2540USB/usb/class_hid/: usb_class_requests.c usb_class_requests.h usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h usb_hid.c usb_hid.h usb_hid_descriptor.s51 usb_hid_hooks.c usb_hid_reports.c usb_hid_reports.h
  group HAL/Target/CC2540USB/USB/library
    ../../../../Components/hal/target/CC2540USB/usb/library/: usb_descriptor.h usb_framework.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group HAL/Target/CC2540USB/USB/library/cc2540_hid
    ../../../../Components/hal/target/CC2540USB/usb/library/cc2540_hid/: usb_board_cfg.h usb_interrupt.c usb_suspend.c
  group HAL/Target/CC2540USB/USB/library/usb_hid
    ../../../../Components/hal/target/CC2540USB/usb/library/usb_hid/: usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework_structs.h usb_interrupt.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/CC254x/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2540DB/bin/: CC2540_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi_spi.c npi_uart.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Batt/CC254x/: battservice.c battservice.h
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/GATT/: gattservapp_util.c
    ../../Profiles/HIDDev/CC254x/: hiddev.c hiddev.h
    ../../Profiles/HIDDevKbd/CC254x/: hidkbdservice.c
    ../../Profiles/HidDevKbd/: hidkbdservice.h
    ../../Profiles/Roles/CC254x/: peripheral.c peripheral.h
    ../../Profiles/ScanParam/CC254x/: scanparamservice.c
    ../../Profiles/ScanParam/: scanparamservice.h
    ../../Profiles/SimpleProfile/CC254x/: simpleGATTprofile.c
    ../../Profiles/SimpleProfile/: simpleGATTprofile.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
