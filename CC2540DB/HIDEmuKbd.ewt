<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>CC2540DK-MINI Keyfob Slave</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\..\Source\Adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Display_EPD_W21.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Display_EPD_W21_Aux.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\hidemukbd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\hidemukbd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\hidemukbd_Main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\OSAL_hidemukbd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\Pwm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\spi.c</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>Common</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\common\hal_drivers.c</name>
      </file>
    </group>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_defs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_drivers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_key.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_lcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_led.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_rpc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_sleep.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_uart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\services\saddr\saddr.h</name>
      </file>
    </group>
    <group>
      <name>Target</name>
      <group>
        <name>CC2540USB</name>
        <group>
          <name>Config</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_board_cfg.h</name>
          </file>
        </group>
        <group>
          <name>Drivers</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_aes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_key.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_lcd.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_sleep.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_startup.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_timer.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_uart.c</name>
          </file>
        </group>
        <group>
          <name>Includes</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_aes.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_dma.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_mcu.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\hal_types.h</name>
          </file>
        </group>
        <group>
          <name>USB</name>
          <group>
            <name>class_hid</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_hid\usb_class_requests.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_hid\usb_class_requests.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_hid\usb_firmware_library_config.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_hid\usb_firmware_library_config.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_hid\usb_firmware_library_headers.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_hid\usb_hid.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_hid\usb_hid.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_hid\usb_hid_descriptor.s51</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_hid\usb_hid_hooks.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_hid\usb_hid_reports.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\class_hid\usb_hid_reports.h</name>
            </file>
          </group>
          <group>
            <name>library</name>
            <group>
              <name>cc2540_hid</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\cc2540_hid\usb_board_cfg.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\cc2540_hid\usb_interrupt.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\cc2540_hid\usb_suspend.c</name>
              </file>
            </group>
            <group>
              <name>usb_hid</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_hid\usb_descriptor_parser.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_hid\usb_descriptor_parser.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_hid\usb_framework.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_hid\usb_framework_structs.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_hid\usb_interrupt.h</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_descriptor.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_framework.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_reg.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_standard_requests.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_standard_requests.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540USB\usb\library\usb_suspend.h</name>
            </file>
          </group>
        </group>
      </group>
    </group>
  </group>
  <group>
    <name>INCLUDE</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\att.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\gap.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\gatt.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\gatt_uuid.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\hci.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\l2cap.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\host\linkdb.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\controller\CC254x\include\ll.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\npi\npi_np\npi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\controller\CC254x\include\phy.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\sm.h</name>
    </file>
  </group>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2540DB\bin\CC2540_BLE_peri.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_None.lib</name>
    </file>
  </group>
  <group>
    <name>NPI</name>
    <file>
      <name>$PROJ_DIR$\..\..\common\npi\npi_np\npi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\npi\npi_np\npi_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\npi\npi_np\npi_uart.c</name>
    </file>
  </group>
  <group>
    <name>OSAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\bcomdef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\osal_bufmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\osal_cbtimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_ClockBLE.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_Memory.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_PwrMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\mcu\cc2540\osal_snv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_Timers.c</name>
    </file>
  </group>
  <group>
    <name>PROFILES</name>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Batt\CC254x\battservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Batt\CC254x\battservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DevInfo\devinfoservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DevInfo\devinfoservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gapbondmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gapbondmgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Include\gapgattserver.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\host\gatt_uuid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Include\gattservapp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\GATT\gattservapp_util.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\HIDDev\CC254x\hiddev.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\HIDDev\CC254x\hiddev.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\HIDDevKbd\CC254x\hidkbdservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\HIDDevKbd\hidkbdservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\CC254x\peripheral.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\CC254x\peripheral.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\ScanParam\CC254x\scanparamservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\ScanParam\scanparamservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SimpleProfile\CC254x\simpleGATTprofile.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SimpleProfile\simpleGATTprofile.h</name>
    </file>
  </group>
  <group>
    <name>TOOLS</name>
    <file>
      <name>$PROJ_DIR$\..\..\config\buildComponents.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\buildConfig.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\cc2540\OnBoard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\cc2540\OnBoard.h</name>
    </file>
  </group>
</project>


